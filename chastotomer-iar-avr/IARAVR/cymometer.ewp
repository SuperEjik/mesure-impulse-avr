# IAR project cymometer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 40
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm8535.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: bcd.c lcd_lib.c main.c timer.c
